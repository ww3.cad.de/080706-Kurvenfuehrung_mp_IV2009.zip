# Autodesk Inventor assembly: 080709-10-001
## iProperties
Created: 2008-07
Part Number: 080709-10-001
Document SubType Name: Assembly
Designer: WH
Stock Number: 080709-10-001
Author: WH
